<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F401_pinout.ewp</path>
  </project>
  <batchBuild />
</workspace>
